Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2016-06-14T14:55:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160525_1230(x64) - Exporter 16.0.1144.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 14 14:55:47 2016 * Host: gebruiker-PC * Database: C:\Users\GEBRUI~1\AppData\Local\Temp\{5FCBD77E-9C74-4B34-85D9-846A08928884}\ifc * Database version: 5507 * Database creation date: Tue Jun 14 14:55:46 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 14 14:55:46 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 14 14:55:46 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: D42R1 LEDN3540S, Dummy:D42R1 LEDN3540S:209129
In: Level 1
Type - Material: BE_G Glas lamp, BE Armatuur
Type - Constraints - Default Elevation: 1000 mm; WT_H B*: 0 mm; WT_H Behuizing: Standaard; WT_H Breedte: 250 mm; WT_H Coarse geometrie: 250; WT_H Diameter: 240 mm; WT_H Einde void: -74 mm; WT_H Grid_breedte: 300 mm; WT_H Grid_lengte: 1200 mm; WT_H Haakse wandmontage: no; WT_H Halve breedte: 125 mm; WT_H Halve breedte negatief: -125 mm; WT_H Halve hoogte: 37 mm; WT_H Halve hoogte negatief: -37 mm; WT_H Halve hoogte symbool: 125 mm; WT_H Halve lengte: 125 mm; WT_H Halve lengte negatief: -125 mm; WT_H Hoogte: 74 mm; WT_H Hoogte optiek: 1 mm; WT_H Inbouw: yes; WT_H Inbouwdiepte: 74 mm; WT_H Inbouwdiepte negatief: -74 mm; WT_H Lengte: 250 mm; WT_H Offset lichtbron: 0 mm; WT_H Referentie: Inbouw; WT_H Rotatie in vlak: 0 deg; WT_H Rotatie rond as: 0 deg; WT_H Rotatie uit vlak: 0 deg; WT_H Start void: 0 mm; WT_H Symbool plafond hoogte: 250 mm; WT_H Symbool plafond lengte: 250 mm; WT_H Symbool straal: 125 mm; WT_H Symbool wand hoogte: 74 mm; WT_H Symbool wand lengte: 250 mm; WT_H Uitsnijding_diameter: 230 mm; WT_H Uitsnijding_straal: 115 mm; WT_H Uitsteek: 0 mm
Type - Dimensions - BE_G Breedte: 250 mm; BE_G Diameter: 250 mm; BE_G Hoogte: 74 mm; BE_G Lengte: 250 mm
Type - Electrical - BE_E Arbeidsfactor: 1; BE_E Belastingsklasse: Verlichting; BE_E Schijnbaar vermogen: 351 W; BE_E Spanning: 230 V
Type - Electrical - Loads - Apparent Load: 351 W
Type - Graphics - WT_V Symbool plafond: Ronde armatuur; WT_V Symbool wand: Geen
Type - Identity Data - BE_I Bestelcode: D42R1/LEDN3540S; Manufacturer: ETAP; Model: D4; Type Name: D42R1 LEDN3540S; WT_I BaseKeynote: 63.1
Type - Materials and Finishes - WT_V Materiaal armatuur: BE Armatuur; WT_V Materiaal kader: BE Kader
Type - Model Properties - WT_I Armatuurrendement: 0; WT_I Dimbaar: -; WT_I IP klasse: IP40; WT_I Kleur: -; WT_I Maatschets catalogus: -; WT_I Maximale temperatuur: -; WT_I Montage: Inbouw; WT_I Optiek: Lens - breedstralend; WT_I UGR: <=22; WT_I Voorschakelapparaat: s; WT_I Vorm: rond
Type - Other - Category: Lighting Fixtures; Family Name: Dummy; WT_c1 Omschrijving: c1_Elektrische voeding
Type - Photometrics - WT_H Lichtbron: BE_E_GEO Armatuur_ETAP D4 - lichtbron: D42R1_LEDN3540_S; WT_I Aantal lampen: 1; WT_I Afschermhoek: 0 deg; WT_I Lamptype: High Powerled; WT_I Luminantie: 0; WT_I Vermogen lamp: 351 W
Pset_ManufacturerTypeInformation - Manufacturer: ETAP
Pset_DistributionFlowElementCommon - Reference: D42R1 LEDN3540S
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; WT_H Uitsnijding_straal_: 115 mm
Dimensions - Area: 0.370178 m2; Volume: 0.0166025 m3
Electrical - Circuiting - Electrical Data: c1_Elektrische voeding 230 V/1-351 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 17
Other - Family: Dummy: D42R1 LEDN3540S; Family and Type: Dummy: D42R1 LEDN3540S; Schedule Level: Level: Level 1; Type: Dummy: D42R1 LEDN3540S; Type Id: Dummy: D42R1 LEDN3540S
Phasing - Phase Created: 469492
